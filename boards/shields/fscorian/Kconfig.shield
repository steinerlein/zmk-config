## config/boards/shields/fscorian/Kconfig.defconfig
```kconfig
if SHIELD_FSCORIAN

config ZMK_KEYBOARD_NAME
    default "FS Keyboard"
    CONFIG_ZMK_SLEEP=Y 
endif
```
